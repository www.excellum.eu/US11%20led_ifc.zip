Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T08:27:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 08:27:33 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{42F49386-F254-4D63-95A6-993D716D2A8E}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 08:27:32 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 08:27:33 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 08:27:33 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: US11K1 LEDW40S, Dummy:US11K1 LEDW40S:207424
In: Level 1
Type - PredefinedType: DIRECTIONSOURCE; Material: BE_G Glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: 151; WT_H Behuizing_medium en coarse: 151; WT_H Breedte: 595 mm; WT_H Einde void: -39 mm; WT_H Halve breedte negatief: -297.5 mm; WT_H Halve lengte negatief: -297.5 mm; WT_H Hoogte: 40 mm; WT_H Inbouwdiepte negatief: -39 mm; WT_H Lengte: 595 mm; WT_H Offset lichtbron: 1 mm; WT_H Start void: 0 mm; WT_H Symbool plafond hoogte: 595 mm; WT_H Symbool plafond lengte: 595 mm; WT_H Symbool wand hoogte: 50 mm; WT_H Symbool wand lengte: 595 mm; WT_H Uitsteek: 1 mm
Type - Construction - WT_V Inbouw: yes; WT_V Inbouwbreedte: 580 mm; WT_V Inbouwdiepte: 39 mm; WT_V Inbouwlengte: 580 mm
Type - Dimensions - BE_G Breedte: 595 mm; BE_G Hoogte: 40 mm; BE_G Lengte: 595 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 376 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Graphics - WT_V Symbool plafond: TL-armatuur met 1 lamp; WT_V Symbool wand: Geen
Type - Identity Data - BE_I Bestelcode: US11K1/LEDW40S; Manufacturer: ETAP; Model: US11; RS_C_drs_content_creator: © Witas; RS_C_drs_content_provider: Etap; RS_C_fabrikant_artikelcode: US11K1/LEDW40S; RS_C_fabrikant_bibliotheek_versie: 1; RS_C_fabrikant_jaartal: 2015; RS_C_IFC_versie: 2x3; RS_C_revit_versie: 2012; Type Comments: verlichtingsarmatuur; Type Name: US11K1 LEDW40S; URL: http://www.etaplighting.com/level3.aspx?seq=129&seqpicture=2565&name=US11&icon1=1065&icon2=2323&LangType=2067; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Diffusor_materiaal: BE Glas - lamp; WT_V Materiaal armatuur: BE Armatuur
Type - Model Properties - WT_I Armatuurrendement: 9; WT_I IP: IP20; WT_I Kleur: RAL9210; WT_I Lichtverdeling: zeer breedstalend; WT_I Maatschets catalogus: 151; WT_I Maximale temperatuur: 850°C; WT_I Montage: inbouw; WT_I Type: individueel; WT_I UGR: <=22; WT_I Vorm: vierkant
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP US11 - lichtbron - led: US11K1_LEDW40_S; WT_I Lamptype: Low PowerLed; WT_I Luminantie: 7.98966; WT_I Optiek: softlight; WT_I Vermogen lamp: 376 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: US11K1 LEDW40S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 1.60816 m2; Volume: 0.0559246 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-376 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 33
Other - Family: Dummy: US11K1 LEDW40S; Family and Type: Dummy: US11K1 LEDW40S; Schedule Level: Level: Level 1; Type: Dummy: US11K1 LEDW40S; Type Id: Dummy: US11K1 LEDW40S
Phasing - Phase Created: 469492
Text - WT_I Revit handleiding: www.witas.be/etap
